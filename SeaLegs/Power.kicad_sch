File: SeaLegs/Power.kicad_sch (KiCad schematic)
At the start: 18 parts, among them J1 Conn_01x02, U2 BQ21040, U3 BQ2982

Commit message: updated requirements
Parts:
- U7: value ~ -> (none)
